Commit message: add PILZ planner

File: frcobot_description/urdf/fr3_gazebo.urdf (robot description, URDF)
Before this commit: robot FR3-V5.0, 10 links, 9 joints
Joints:
- joint ground_plane_box: origin xyz=0 0 -0.0025 rpy=0 0 0 -> xyz=0 0 -0.005 rpy=0 0 0
